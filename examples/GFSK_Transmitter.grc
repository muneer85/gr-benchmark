options:
  parameters:
    author: Dr. Muneer AlZuBi
    copyright: Muneer AlZuBi
    description: This example illustrate how to use the Benchmark Test Block.
    generate_options: qt_gui
    id: BenchmarkTest
    output_language: python
    title: GFSK Transmitter
  states: {}

blocks:
- name: FFT_Iter
  id: variable
  parameters:
    value: '10'
  states: {}
- name: Num_sent_pkts
  id: variable
  parameters:
    value: int(file_size/pck_len)
  states: {}
- name: Vector_Size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bw
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: f
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: file_size
  id: variable
  parameters:
    value: '516096  '
  states: {}
- name: gain_tx
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pck_len
  id: variable
  parameters:
    value: '500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/muneer/examples/Guglielmo Marconi.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: pck_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    name: ''
    size: Vector_Size
    type: complex
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: Vector_Size
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bw
    center_freq0: f
    dev_addr: '"addr=192.168.10.2"'
    gain0: gain_tx
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: header
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_gfsk_mod_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_const_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_sink_x_2, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_tagged_stream_mux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
