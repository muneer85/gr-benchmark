options:
  parameters:
    author: Dr. Muneer AlZuBi
    copyright: Muneer AlZuBi
    description: This example illustrate how to use the Benchmark Test Block.
    generate_options: qt_gui
    id: BenchmarkTest
    output_language: python
    title: GFSK Receiver with Benchmark Test
  states: {}

blocks:
- name: FFT_Iter
  id: variable
  parameters:
    value: '10'
  states: {}
- name: Num_sent_pkts
  id: variable
  parameters:
    value: int(file_size/pck_len)
  states: {}
- name: Vector_Size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bw
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: f
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: file_size
  id: variable
  parameters:
    value: '188416'
  states: {}
- name: gain_rx
  id: variable
  parameters:
    value: '1'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pck_len
  id: variable
  parameters:
    value: '500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Benchmark_Test_Benchmark_1
  id: Benchmark_Test_Benchmark
  parameters:
    Ant_gain: 3 dBi
    N_disc_packtet: '0'
    Note: We use VERT2450 Antenna
    Num_sent_Packets: Num_sent_pkts
    ch_bw: bw
    file_out: output.csv
    freq_center: f
    iter_avg: FFT_Iter
    mod_order: mod_order
    packet_length: pck_len
    sample_rate: samp_rate
    test_mode: '0'
    time_zone: Asia/Riyadh
    tx_power: 0.5 gain
    vector_size: Vector_Size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.wav
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_Size
    type: complex
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: ' ''11100001010110101110100010010011'''
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
    swap_endianness: 'True'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: Vector_Size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(Vector_Size)
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: Vector_Size
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    update_time: '0.001'
    vlen: Vector_Size
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: bw
    center_freq0: f
    dev_addr: '"addr=192.168.10.2"'
    gain0: gain_rx
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: CRC_In
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: FFT_In
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: CRC_In
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: FFT_In
  states: {}

connections:
- [Benchmark_Test_Benchmark_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0, '0']
- [digital_crc_check_0, fail, Benchmark_Test_Benchmark_1, msg_in_fail]
- [digital_crc_check_0, ok, Benchmark_Test_Benchmark_1, msg_in_ok]
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [fft_vxx_0, '0', Benchmark_Test_Benchmark_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_check_0, in]
- [uhd_usrp_source_0, '0', digital_gfsk_demod_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
